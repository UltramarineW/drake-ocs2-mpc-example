Commit message: feat: 加入在meshcat中可以手动更改target position

File: src/mpc_double_integrator/double_integrator.urdf (robot description, URDF)
Before this commit: robot double_integrator, 3 links, 2 joints
Links:
- removed link target
Joints:
- removed joint slider_to_target
